** sch_path: examples/sq_1nH_2.5GHz/xschem/lc_ideal.sch
**.subckt lc_ideal p1 p2
*.iopin p1
*.iopin p2
C1 p1 p2 4.0528p m=1
L1 p1 p2 1n m=1
**.ends
.end
